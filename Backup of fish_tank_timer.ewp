# IAR project Backup of fish_tank_timer.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  XLINK.XclFile: applilet3_src\md_lnkr5f100le.xcl
configuration Release (RL78)
  as the first configuration, except:
  group applilet_src
    applilet3_src/: r_main.c r_systeminit.c r_cg_cgc.c r_cg_cgc_user.c r_cg_port.c r_cg_port_user.c r_cg_wdt.c r_cg_wdt_user.c r_cg_rtc.c r_cg_rtc_user.c
